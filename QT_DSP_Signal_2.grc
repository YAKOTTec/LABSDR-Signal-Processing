options:
  parameters:
    author: YAKOTT
    copyright: YAKOTT
    generate_options: qt_gui
    id: QT_DSP_Signal_2
    output_language: python
    title: QT_DSP_Signal_2
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    comment: Amplitude of the signal.
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: Phi
  id: variable_qtgui_range
  parameters:
    comment: Phase of the signal.
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: 2*np.pi
    value: '0'
  states: {}
- name: Tasa_de_Muestreo
  id: variable_qtgui_range
  parameters:
    comment: Sample Rate operation.
    orient: Qt.Horizontal
    start: 1e3
    step: '1'
    stop: 10e3
    value: 5e3
  states: {}
- name: fo
  id: variable_qtgui_range
  parameters:
    comment: Frequency  of the signal.
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '50'
  states: {}
- name: t
  id: variable
  parameters:
    value: np.linspace(0.0,1.0,Tasa_de_Muestreo)
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Reduce CPU usage.
    samples_per_second: Tasa_de_Muestreo
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Create a signal.
    repeat: 'True'
    type: float
    vector: A*(np.cos((2*np.pi*fo*t)+Phi))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"x(t)"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"|x(t)|"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}

connections:
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_abs_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
