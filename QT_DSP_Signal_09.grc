options:
  parameters:
    author: YAKOTT
    copyright: YAKOTT
    generate_options: qt_gui
    id: QT_DSP_Signal_9
    output_language: python
    title: QT_DSP_Signal_9
  states: {}

blocks:
- name: Tasa_de_Muestreo
  id: variable_qtgui_range
  parameters:
    comment: Sample Rate operation.
    orient: Qt.Horizontal
    start: 1e3
    step: '1'
    stop: 10e3
    value: 5e3
  states: {}
- name: fo
  id: variable_qtgui_range
  parameters:
    comment: Frequency  of the signal.
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '50'
  states: {}
- name: t
  id: variable
  parameters:
    value: np.linspace(0.0,1.0,Tasa_de_Muestreo)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Reduce CPU usage.
    samples_per_second: Tasa_de_Muestreo
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Create a signal.
    repeat: 'True'
    type: complex
    vector: np.cos(2*np.pi*fo*t)+(1j*np.sin(2*np.pi*fo*t))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: Tasa_de_Muestreo
    comment: Plot signal over frequency.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"X(jw)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
