options:
  parameters:
    author: YAKOTT
    copyright: YAKOTT
    generate_options: qt_gui
    id: QT_DSP_Signal_8
    output_language: python
    title: QT_DSP_Signal_8
  states: {}

blocks:
- name: Tasa_de_Muestreo
  id: variable_qtgui_range
  parameters:
    comment: Sample Rate operation.
    orient: Qt.Horizontal
    start: 1e3
    step: '1'
    stop: 10e3
    value: 5e3
  states: {}
- name: fo
  id: variable_qtgui_range
  parameters:
    comment: Frequency  of the signal.
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '50'
  states: {}
- name: t
  id: variable
  parameters:
    value: np.linspace(0.0,1.0,Tasa_de_Muestreo)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Reduce CPU usage.
    samples_per_second: Tasa_de_Muestreo
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Create a signal.
    repeat: 'True'
    type: float
    vector: (np.cos(2*np.pi*fo*t))
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Plot signal over frequency.
    grid: 'True'
    name: '"X(jw)"'
    vlen: '1024'
    x_axis_label: '"Frequency"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Relative Gain (dB)"'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_float_to_complex_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
