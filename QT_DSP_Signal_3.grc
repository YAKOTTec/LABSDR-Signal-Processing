options:
  parameters:
    author: YAKOTT
    copyright: YAKOTT
    generate_options: qt_gui
    id: QT_DSP_Signal_3
    output_language: python
    title: QT_DSP_Signal_3
  states: {}

blocks:
- name: A1
  id: variable_qtgui_range
  parameters:
    comment: Amplitude of the signal.
    gui_hint: Parametros@0:(0,0,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: A2
  id: variable_qtgui_range
  parameters:
    comment: Amplitude of the signal.
    gui_hint: Parametros@0:(0,1,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: Phi1
  id: variable_qtgui_range
  parameters:
    comment: Phase of the signal.
    gui_hint: Parametros@0:(2,0,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: 2*np.pi
    value: '0'
  states: {}
- name: Phi2
  id: variable_qtgui_range
  parameters:
    comment: Phase of the signal.
    gui_hint: Parametros@0:(2,1,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: 2*np.pi
    value: '0'
  states: {}
- name: Tasa_de_Muestreo
  id: variable_qtgui_range
  parameters:
    comment: Sample Rate operation.
    gui_hint: (0,0,1,1)
    orient: Qt.Horizontal
    start: 1e3
    step: '1'
    stop: 10e3
    value: 5e3
  states: {}
- name: fo1
  id: variable_qtgui_range
  parameters:
    comment: Frequency  of the signal.
    gui_hint: Parametros@0:(1,0,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '50'
  states: {}
- name: fo2
  id: variable_qtgui_range
  parameters:
    comment: Frequency  of the signal.
    gui_hint: Parametros@0:(1,1,1,1)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '50'
  states: {}
- name: t
  id: variable
  parameters:
    value: np.linspace(0.0,1.0,Tasa_de_Muestreo)
  states: {}
- name: Parametros
  id: qtgui_tab_widget
  parameters:
    gui_hint: (1,0,1,1)
    label0: Variables
    num_tabs: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A2
    comment: Create a signal.
    freq: fo2
    offset: Phi2
    phase: '0'
    samp_rate: Tasa_de_Muestreo
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Reduce CPU usage.
    samples_per_second: Tasa_de_Muestreo
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Create a signal.
    repeat: 'True'
    type: float
    vector: A1*(np.cos((2*np.pi*fo1*t)+Phi1))
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"x1(t)+x2(t)"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"x1(t)-x2(t)"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"x1(t)x2(t)"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Plot signal over time.
    grid: 'True'
    name: '"x1(t)/x2(t)"'
    size: '1024'
    srate: Tasa_de_Muestreo
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_sub_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', blocks_divide_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
